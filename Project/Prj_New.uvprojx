# Keil uVision project Prj_New.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F450VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Prj_New +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F450
  c include: ..\Firmware\Peripherals\inc;..\Include;..\User\sys;..\User\systick;..\User\port;..\User\my_usart;..\User\dci_adc;..\User\Hardware\src;..\User\Hardware\inc;..\User\Driver\src;..\User\Driver\inc;..\Firmware\Peripherals\inc;..\Firmware\Peripherals\src;..\User\Driver\SX1278;..\User\APP\inc;..\User\APP\src;..\User\Driver\SIM7020
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT5: ROM 0x810000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c gd32f4xx_it.c
    ../User/systick/: systick.c
    ../User/APP/src/: lora.c crc16.c fmc_flash.c communicate.c service_logic.c
  group CMSIS
    ../Source/: system_gd32f4xx.c
  group Peripherals
    ../Firmware/Peripherals/src/: gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_gpio.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_usart.c gd32f4xx_adc.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_wwdgt.c
  group Doc
    ../Source/ARM/: startup_gd32f450.s
    ../Doc/: Readme.txt
  group Hardware
    ../User/Hardware/src/: gpio_config.c spi_config.c adc_config.c dac_config.c timer_config.c usart_config.c dci_config.c rtc_config.c
  group Driver/sx1278
    ../User/Driver/SX1278/: sx1278.c
  group Driver/sim7020
    ../User/Driver/SIM7020/: at_parse.c at_recv_cb.c at_uart_hal.c dev_sim7020.c net_protocol.c
